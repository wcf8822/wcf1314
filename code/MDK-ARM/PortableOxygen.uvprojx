# Keil uVision project PortableOxygen.uvprojx, settings and files
target PortableOxygen (6140000::V6.14::ARMCLANG)
  device: STM32L152VE STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00014000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: PortableOxygen +hex
  AfterMake: C:\Keil_v5\ARM\ARMCLANG\Bin\fromelf.exe --bin --output=@L.bin !L
  AfterMake: C:\Keil_v5\ARM\ARMCLANG\Bin\fromelf.exe --text -a -c --output=@L.dis !L
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32L152xE
  c include: ../Core/Inc;../Drivers/STM32L1xx_HAL_Driver/Inc;../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L1xx/Include;../Drivers/CMSIS/Include;../gui;../hardware;../logic
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
  group Application/MDK-ARM
    ./: startup_stm32l152xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c iwdg.c spi.c tim.c usart.c stm32l1xx_it.c stm32l1xx_hal_msp.c
  group Drivers/STM32L1xx_HAL_Driver
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_dma.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_cortex.c stm32l1xx_hal_exti.c stm32l1xx_hal_iwdg.c stm32l1xx_hal_spi.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l1xx.c
  group gui
    ../gui/: loadbit.c GUI_BASIC.c GUI_StockC.c font_lib.c interfacial.c label.c option.c nano_option.c generate_page.c
  group hardware
    ../hardware/: bmp280.c spa06.c lcd_drive.c rs485.c rtc.c soft_iic.c spi_flash.c key.c heart.c gps.c data_processing.c ch340e.c battery.c bee.c
  group logic
    ../logic/: logic.c setting.c dissolved_oxygen.c log.c algorith.c NH3N_DN02.c COD_DC18.c DO_shenghui.c NH3N_shenghui.c COD_shenghui.c pH_shenghui.c Tur_shenghui.c EC_shenghui.c EC_DE26.c pH_DpH07.c Chl_shenghui.c ORP_DR31.c BGA_shenghui.c MLSS_Tianjian.c OiW_Guohong.c OiW_yushan.c DO_HaiFa_DY12.c DO_HaiFa_DY56.c DX01.c MLSS_lanchang.c EC_DE40.c DZ09.c TDS_DT49.c DL312.c DY05.c DO59.c
software components: CMSIS:CORE 5.4.0
